<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Team_Twist.ewp</path>
  </project>
  <batchBuild/>
</workspace>


